* Descriptions ===================================================
*
* Autor: Allan Appelt Constante
* Data:  29/08/2019
*
* ================================================================

* Tech files =====================================================
.include 'modelfiles/hp/14nfet.pm'
.include 'modelfiles/hp/14pfet.pm'
* ================================================================
